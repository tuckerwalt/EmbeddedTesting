# Keil uVision project STCubeGenerated.uvprojx, settings and files
target STCubeGenerated (ARM-ADS)
  device: STM32C031C6Tx STMicroelectronics
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STCubeGenerated +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32C031xx
  c include: ../Inc;C:/Users/JoeBob/STM32Cube/Repository/STM32Cube_FW_C0_V1.2.0/Drivers/STM32C0xx_HAL_Driver/Inc;C:/Users/JoeBob/STM32Cube/Repository/STM32Cube_FW_C0_V1.2.0/Drivers/STM32C0xx_HAL_Driver/Inc/Legacy;C:/Users/JoeBob/STM32Cube/Repository/STM32Cube_FW_C0_V1.2.0/Drivers/CMSIS/Device/ST/STM32C0xx/Include;C:/Users/JoeBob/STM32Cube/Repository/STM32Cube_FW_C0_V1.2.0/Drivers/CMSIS/Include
  group Application/MDK-ARM
    ./: startup_stm32c031xx.s
  group Application/User
    ../Src/: main.c stm32c0xx_it.c stm32c0xx_hal_msp.c
  group Drivers/STM32C0xx_HAL_Driver
    C:/Users/JoeBob/STM32Cube/Repository/STM32Cube_FW_C0_V1.2.0/Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_hal_cortex.c stm32c0xx_hal.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_dma.c stm32c0xx_hal_dma_ex.c stm32c0xx_hal_pwr.c stm32c0xx_hal_pwr_ex.c stm32c0xx_hal_exti.c stm32c0xx_hal_tim.c stm32c0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32c0xx.c
software components: CMSIS:CORE 4.3.0
